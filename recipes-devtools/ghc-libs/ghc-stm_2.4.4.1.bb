require recipes-devtools/ghc-libs/ghc-lib-common.inc
SRC_URI[md5sum] = "480b37cce3d35c11fd67bf9df957ae19"
SRC_URI[sha256sum] = "8f999095ed8d50d2056fc6e185035ee8166c50751e1af8de02ac38d382bf3384"

DESCRIPTION = "A modular composable concurrency abstraction."
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM="file://LICENSE;md5=7e68525a4e43257669c0c08c1dbedb81"
GHC_PN = "stm"
