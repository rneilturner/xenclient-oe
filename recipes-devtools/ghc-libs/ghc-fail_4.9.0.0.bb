BBCLASSEXTEND = "native"
SRC_URI[md5sum] = "e2bc7fe2a5c1518acb0b5b5b9b1b4723"
SRC_URI[sha256sum] = "6d5cdb1a5c539425a9665f740e364722e1d9d6ae37fbc55f30fe3dbbbb91d4a2"
require recipes-devtools/ghc-libs/ghc-lib-common.inc

DESCRIPTION = "This package contains the Control.Monad.Fail"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=3d3541c743c2c2388acf3ce484d31744"
GHC_PN = "fail"
